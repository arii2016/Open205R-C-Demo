# Keil uVision project USB_Host_device.uvproj, settings and files
target STM3210C-EVAL_USBH-FS (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,USE_STM3210C_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c usbd_usr.c dual_func_demo.c main.c usbd_storage_msd.c usbh_msc_usr.c usbd_desc.c
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f2xx.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c stm32_eval_sdio_sd.c
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_ioe.c
    ../src/: LTM022A69B.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_usart.c stm32f2xx_tim.c stm32f2xx_sdio.c
  group FAT FS
    ../../../../Utilities/Third_Party/fat_fs/src/option/: ccsbcs.c
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c
  group USB Device
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_scsi.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c
  group USB Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c usb_hcd_int.c usb_hcd.c
  group USB Host
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
  group Doc
    ../: readme.txt
target STM322xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM322xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
