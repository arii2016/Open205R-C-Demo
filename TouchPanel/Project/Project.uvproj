# Keil uVision project Project.uvproj, settings and files
target Open205R (ARM-ADS)
  device: STM32F205RB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\User\SysTick;..\User\Touchpanel;..\..\_Common;..\User\LCD22
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f2xx_it.c User_systick.c
    ../../_Common/: config.c config.h
    ../User/Touchpanel/: Touchpanel.c
    ../User/LCD22/: AsciiLib.c LCD22.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_usart.c misc.c stm32f2xx_fsmc.c stm32f2xx_tim.c stm32f2xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
